FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://agc032a_defconfig.append \
           "
