require u-boot-common.inc
require u-boot-tools.inc

PV = "d2019.04"
SRCBRANCH = "openbmc/helium/delta"
SRC_URI = "git://github.com/sw103-openbmc/openbmc-uboot.git;branch=${SRCBRANCH};protocol=https"

